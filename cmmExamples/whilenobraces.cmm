k = 0
while (k < 4) k = k + 1
print k