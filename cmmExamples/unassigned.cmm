x = 1
print x
y = z + 1
print y