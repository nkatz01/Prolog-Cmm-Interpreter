x = 5
print 1
if (x) print 2
print 3
