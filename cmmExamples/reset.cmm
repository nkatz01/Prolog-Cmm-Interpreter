print n